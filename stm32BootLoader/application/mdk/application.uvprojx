# Keil uVision project application.uvprojx, settings and files
target __application (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin .\Objects\application.axf --output .\Objects\application.bin
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\delay;..\uart
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../user/: main.c
    ../delay/: delay.c
    ../uart/: uart.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
